RDEPENDS:${PN}:remove = "connman-client \
                        connman-tools \
                        connman-tests\
                        "
