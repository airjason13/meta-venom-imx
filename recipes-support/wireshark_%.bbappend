
EXTRA_OECMAKE +="-DUSE_Qt6=OFF"
